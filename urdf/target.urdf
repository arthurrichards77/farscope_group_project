Commit message: Reduced mass of target - now more reliable on movement.

File: urdf/target.urdf (robot description, URDF)
Before this commit: robot farscope_target, 1 links, 0 joints
Links:
- link link_0: mass 1 -> 0.05
